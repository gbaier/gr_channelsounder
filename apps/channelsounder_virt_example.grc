<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>gr_null_source</key>
<param><key>id</key><value>gr_null_source_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>degree</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>digital_glfsr_source_x</key>
<param><key>id</key><value>digital_glfsr_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>degree</key><value>degree</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>mask</key><value>0</value></param>
<param><key>seed</key><value>1</value></param>
</block>
<block>
<key>channelsounder_mls_corr</key>
<param><key>id</key><value>channelsounder_mls_corr_0</value></param>
<param><key>degree</key><value>degree</value></param>
<param><key>mask</key><value>0</value></param>
<param><key>seed</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_pulse</value></param>
<param><key>value</key><value>2**degree-1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_meas</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>PRF</value></param>
<param><key>value</key><value>samp_rate/len_pulse/M</value></param>
</block>
<block>
<key>gr_float_to_complex</key>
<param><key>id</key><value>gr_float_to_complex_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>channelsounder_avg_m_over_n_cc</key>
<param><key>id</key><value>channelsounder_avg_m_over_n_cc_0</value></param>
<param><key>m</key><value>M</value></param>
<param><key>win_size</key><value>len_pulse</value></param>
</block>
<block>
<key>gr_skiphead</key>
<param><key>id</key><value>gr_skiphead_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>250</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>cs_sink_c</key>
<param><key>id</key><value>cs_sink_c_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>prf</key><value>PRF</value></param>
<param><key>ntau</key><value>len_pulse</value></param>
<param><key>nt</key><value>n_meas</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100e6/5</value></param>
</block>
<block>
<key>gr_channel_model</key>
<param><key>id</key><value>gr_channel_model_0</value></param>
<param><key>noise_voltage</key><value>1</value></param>
<param><key>freq_offset</key><value>50/samp_rate</value></param>
<param><key>epsilon</key><value>1</value></param>
<param><key>taps</key><value>[1.0 + 1.0j, 0, 0, 0.5, 0, 0, 0, 0, 0, 0, 0.3]</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>0.1</value></param>
</block>
<connection><source_block_id>digital_glfsr_source_x_0</source_block_id><sink_block_id>gr_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_null_source_0</source_block_id><sink_block_id>gr_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>channelsounder_avg_m_over_n_cc_0</source_block_id><sink_block_id>channelsounder_mls_corr_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channelsounder_mls_corr_0</source_block_id><sink_block_id>cs_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_float_to_complex_0</source_block_id><sink_block_id>gr_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_skiphead_0</source_block_id><sink_block_id>channelsounder_avg_m_over_n_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>gr_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_channel_model_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
